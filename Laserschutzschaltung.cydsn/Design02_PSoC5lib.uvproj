# Keil uVision project Design02_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Design02_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h DMA_dma.c DMA_dma.h isr.c isr.h ADC_DelSig.c ADC_DelSig.h ADC_DelSig_PM.c ADC_DelSig_INT.c VDAC8.c VDAC8.h VDAC8_PM.c Fault_aliases.h Fault.c Fault.h Comp_1.c Comp_1.h Comp_1_PM.c Clock_1.c Clock_1.h Filter.c Filter.h Filter_PM.c Filter_PVT.c Filter_PVT.h Filter_RAM_Data.c Filter_Coefficients.c ADC_DelSig_theACLK.c ADC_DelSig_theACLK.h ADC_DelSig_Ext_CP_Clk.c ADC_DelSig_Ext_CP_Clk.h ADC_DelSig_AMux.c ADC_DelSig_AMux.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Comp_2.c Comp_2.h Comp_2_PM.c Clock_2.c Clock_2.h Diode_Pumpseite_aliases.h Comp_3.c Comp_3.h Comp_3_PM.c Diode_Seedseite_aliases.h Diode_Seedseite.c Diode_Seedseite.h Seed_ref_aliases.h Seed_ref.c Seed_ref.h Pump_ref_aliases.h Pump_ref.c Pump_ref.h DAC_Out_aliases.h Status_Reg.c Status_Reg.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h Fault_isr.c Fault_isr.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Design02_PSoC5lib (library)
